# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LCD_ILI9325
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c uart.c uart.h systick.c systick.h lcd.c lcd.h interface.c interface.h calligraphy.c calligraphy.h generator_ctrl.c generator_ctrl.h waves_lut.c waves_lut.h
  group lcd_lib
    ./lcd_lib/: asciiLib.c asciiLib.h LCD_ILI9325.c LCD_ILI9325.h Open1768_LCD.c Open1768_LCD.h Readme
  group tp_lib
    ./tp_lib/: TP_Open1768.c TP_Open1768.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
